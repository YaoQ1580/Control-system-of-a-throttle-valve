# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RD STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F103xE
  c include: .;..\rt-thread-master\include;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\rt-thread-master\libcpu\arm\common;..\rt-thread-master\libcpu\arm\cortex-m3;..\rt-thread-master\components\dfs\include;..\rt-thread-master\components\dfs\filesystems\devfs;..\rt-thread-master\components\drivers\include;..\rt-thread-master\components\drivers\include;..\rt-thread-master\components\drivers\include;..\rt-thread-master\components\drivers\include;..\rt-thread-master\components\finsh;..\rt-thread-master\components\libc\compilers\armlibc;..\rt-thread-master\components\libc\compilers\common;..\rt-thread-master\components\libc\termios;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\libraries\STM32F1xx_HAL\CMSIS\Include;.\applications\inc
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../rt-thread-master/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_soft_i2c.c drv_adc.c drv_common.c
  group cpu
    ../rt-thread-master/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../rt-thread-master/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Filesystem
    ../rt-thread-master/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../rt-thread-master/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../rt-thread-master/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../rt-thread-master/components/drivers/misc/: pin.c adc.c
    ../rt-thread-master/components/drivers/serial/: serial.c
    ../rt-thread-master/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../rt-thread-master/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../rt-thread-master/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../rt-thread-master/components/libc/compilers/common/: gmtime_r.c
    ../rt-thread-master/components/libc/termios/: posix_termios.c
  group STM32_HAL
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_sram.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_i2c.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Application
    ./applications/src/: main.c miscellaneousTools.c MotorThread.c SaveposThread.c ModbusRTUThread.c DataThread.c PressAdjThread.c UpCpuModbusThread.c GlobalVariable.c CaliVariable.c TestThread.c
    ./applications/inc/: miscellaneousTools.h GlobalVariable.h
